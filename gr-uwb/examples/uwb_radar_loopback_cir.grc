options:
  parameters:
    author: UWB GNU Radio Project
    comment: Message-only monostatic radar chain (no UHD)
    description: PacketSource -> LoopbackEcho -> CirEstimator -> CirWriter. Message strobe drives one TX PDU per PRI; a software echo channel (integer/fractional delay, multipath, AWGN) is estimated to per-pulse CIR files.
    generate_options: no_gui
    id: uwb_radar_loopback_cir
    output_language: python
    run_options: run
    title: UWB Radar Loopback CIR
  states: {}

blocks:
- name: cir_post
  id: variable
  parameters:
    comment: CIR taps after the predicted SYNC origin
    value: '100'
  states: {}
- name: cir_pre
  id: variable
  parameters:
    comment: CIR taps before the predicted SYNC origin
    value: '16'
  states: {}
- name: echo_delays
  id: variable
  parameters:
    comment: Echo path delays in samples at 998.4 MS/s (fractional allowed)
    value: (251.5, 1200.0)
  states: {}
- name: echo_gains
  id: variable
  parameters:
    comment: Complex gains, one per echo path
    value: (0.8, 0.35)
  states: {}
- name: pri_ms
  id: variable
  parameters:
    comment: Message-strobe period; drives one emit per PRI
    value: int(pri_s * 1000)
  states: {}
- name: pri_s
  id: variable
  parameters:
    comment: Radar PRI
    value: '0.005'
  states: {}
- name: work_rate
  id: variable
  parameters:
    comment: CIR estimator work rate
    value: 998.4e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: One emit per PRI; remove and set auto_emit=True for a single pulse
    msg: pmt.make_dict()
    period: pri_ms
  states: {}
- name: output_dir
  id: parameter
  parameters:
    label: CIR output directory
    type: str
    value: '''/tmp/uwb-radar-cir'''
  states: {}
- name: packet_file
  id: parameter
  parameters:
    comment: Needs metadata.json (or metadata.fc32.json) beside the packet
    label: TX packet file
    type: str
    value: '''testdata/uwb_radar/tx_998p4.cf32'''
  states: {}
- name: template_file
  id: parameter
  parameters:
    comment: Single 1016-sample SYNC symbol, CF32, at 998.4 MS/s
    label: SYNC template
    type: str
    value: '''testdata/uwb_radar/sync_template_998p4.cf32'''
  states: {}
- name: uwb_cir_writer_0
  id: uwb_cir_writer
  parameters:
    base_name: cir
    directory: output_dir
    queue_capacity: '64'
    write_normalized: 'True'
  states: {}
- name: uwb_loopback_echo_0
  id: uwb_loopback_echo
  parameters:
    comment: Software echo channel replaces UHD TX/RX
    delay_samples: echo_delays
    gains: echo_gains
    max_rx_samples: '524288'
    max_tx_samples: '262144'
    noise_std: '0.0'
    num_delay_samps: '0'
    pre_guard_samples: '1997'
    pri_s: pri_s
    rng_seed: '1'
    t0_s: '0'
    tail_samples: '4096'
  states: {}
- name: uwb_radar_cir_estimator_0
  id: uwb_radar_cir_estimator
  parameters:
    cir_post: cir_post
    cir_pre: cir_pre
    cir_repetitions: '0'
    cir_skip_initial: '10'
    code_index: '9'
    emit_normalized: 'True'
    queue_capacity: '64'
    sfd_mode: '"4z2"'
    sfd_search_margin: '64'
    sfd_threshold: '0.3'
    sync_refine_margin: '8'
    sync_refine_threshold: '0.3'
    sync_repetitions: '64'
    template_path: template_file
  states: {}
- name: uwb_radar_packet_source_0
  id: uwb_radar_packet_source
  parameters:
    auto_emit: 'False'
    code_index: '9'
    descriptor_path: ''
    path: packet_file
    pri_s: pri_s
    sample_format: '"fc32"'
    sample_rate: work_rate
    sfd_mode: '"4z2"'
    sync_repetitions: '64'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uwb_radar_packet_source_0, emit]
- [uwb_loopback_echo_0, rx, uwb_radar_cir_estimator_0, rx]
- [uwb_radar_cir_estimator_0, cir, uwb_cir_writer_0, cir]
- [uwb_radar_cir_estimator_0, status, blocks_message_debug_0, print]
- [uwb_radar_packet_source_0, tx, uwb_loopback_echo_0, tx]

metadata:
  file_format: 1
