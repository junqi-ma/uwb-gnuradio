options:
  parameters:
    author: UWB GNU Radio Project
    comment: Message-only monostatic radar chain (no UHD). TX = C++ HRP synth.
    description: Synthesize TX. HrpPacketSource -> LoopbackEcho -> CirEstimator -> CirWriter. Default PHY matches the radar golden (code 9, 64 SYNC, 4z2, STS, 22 B PSDU). File-load TX is uwb_radar_loopback_cir.grc.
    generate_options: no_gui
    id: uwb_radar_loopback_cir_synth
    output_language: python
    run_options: run
    title: UWB Radar Loopback CIR (HRP synth)
  states: {}

blocks:
- name: cir_post
  id: variable
  parameters:
    comment: CIR taps after the predicted SYNC origin
    value: '100'
  states: {}
- name: cir_pre
  id: variable
  parameters:
    comment: CIR taps before the predicted SYNC origin
    value: '16'
  states: {}
- name: code_index
  id: variable
  parameters:
    comment: HRP preamble code 9-12
    value: '9'
  states: {}
- name: echo_delays
  id: variable
  parameters:
    comment: Echo path delays in samples at 998.4 MS/s (fractional allowed)
    value: (251.5, 1200.0)
  states: {}
- name: echo_gains
  id: variable
  parameters:
    comment: Complex gains, one per echo path
    value: (0.8, 0.35)
  states: {}
- name: pri_ms
  id: variable
  parameters:
    comment: Message-strobe period; drives one emit per PRI
    value: int(pri_s * 1000)
  states: {}
- name: pri_s
  id: variable
  parameters:
    comment: Radar PRI
    value: '0.005'
  states: {}
- name: sync_repetitions
  id: variable
  parameters:
    comment: SYNC symbols (must match CirEstimator)
    value: '64'
  states: {}
- name: work_rate
  id: variable
  parameters:
    comment: CIR estimator work rate
    value: 998.4e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: One emit per PRI; remove and set auto_emit=True for a single pulse
    msg: pmt.make_dict()
    period: pri_ms
  states: {}
- name: output_dir
  id: parameter
  parameters:
    label: CIR output directory
    type: str
    value: '''/tmp/uwb-radar-cir-synth'''
  states: {}
- name: psdu_hex
  id: parameter
  parameters:
    comment: Canonical radar 20 data + FCS; empty string is a 0-byte PSDU
    label: PSDU hex
    type: str
    value: '''47261DF66F4C1BEF45C8F77CE77BD7D8C4D180FB1221'''
  states: {}
- name: template_file
  id: parameter
  parameters:
    comment: Single 1016-sample SYNC symbol, CF32, at 998.4 MS/s
    label: SYNC template
    type: str
    value: '''testdata/uwb_radar/sync_template_998p4.cf32'''
  states: {}
- name: uwb_cir_writer_0
  id: uwb_cir_writer
  parameters:
    base_name: cir
    directory: output_dir
    queue_capacity: '64'
    write_normalized: 'True'
  states: {}
- name: uwb_loopback_echo_0
  id: uwb_loopback_echo
  parameters:
    comment: Software echo channel replaces UHD TX/RX
    delay_samples: echo_delays
    gains: echo_gains
    max_rx_samples: '4194304'
    max_tx_samples: '4194304'
    noise_std: '0.0'
    num_delay_samps: '0'
    pre_guard_samples: '1997'
    pri_s: pri_s
    rng_seed: '1'
    t0_s: '0'
    tail_samples: '4096'
  states: {}
- name: uwb_radar_cir_estimator_0
  id: uwb_radar_cir_estimator
  parameters:
    cir_post: cir_post
    cir_pre: cir_pre
    cir_repetitions: '0'
    cir_skip_initial: '10'
    code_index: code_index
    comment: sfd_mode/SYNC must match HrpPacketSource
    emit_normalized: 'True'
    queue_capacity: '64'
    sfd_mode: '"4z2"'
    sfd_search_margin: '64'
    sfd_threshold: '0.3'
    sync_refine_margin: '8'
    sync_refine_threshold: '0.3'
    sync_repetitions: sync_repetitions
    template_path: template_file
  states: {}
- name: uwb_hrp_packet_source_0
  id: uwb_hrp_packet_source
  parameters:
    append_fcs: 'False'
    auto_emit: 'False'
    code_index: code_index
    comment: C++ HRP BPRF at 998.4 MS/s. insert_sts requires a 4z SFD.
    insert_sts: 'True'
    peak_amplitude: '0.8'
    pri_s: pri_s
    psdu_hex: psdu_hex
    sfd_mode: '"4z2"'
    sync_repetitions: sync_repetitions
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uwb_hrp_packet_source_0, emit]
- [uwb_loopback_echo_0, rx, uwb_radar_cir_estimator_0, rx]
- [uwb_radar_cir_estimator_0, cir, uwb_cir_writer_0, cir]
- [uwb_radar_cir_estimator_0, status, blocks_message_debug_0, print]
- [uwb_hrp_packet_source_0, tx, uwb_loopback_echo_0, tx]

metadata:
  file_format: 1
