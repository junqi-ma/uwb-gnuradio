options:
  parameters:
    author: UWB GNU Radio Project
    category: UWB
    comment: X410 737.28M -> RFNoC 65/48 -> host 998.4M
    description: X410 RFNoC scheduled radar-window capture skeleton.
    generate_options: no_gui
    id: x410_rfnoc_uwb_scheduled
    output_language: python
    title: X410 RFNoC UWB Scheduled Capture
  states: {}

blocks:
- name: radio_rate
  id: variable
  parameters:
    comment: X410 FPGA radio rate
    value: 737.28e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RFNoC upsampler output / host rate
    value: 998.4e6
  states: {}
- name: first_packet_sample
  id: variable
  parameters:
    comment: Set after acquisition/seed
    value: '10000000'
  states: {}
- name: output_dir
  id: parameter
  parameters:
    label: Output directory
    type: str
    value: '''/data/uwb_capture'''
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    clock_source_0: internal
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: '0'
    block_args: '""'
    dc_offset: 'False'
    device_select: '0'
    frequency: 6.5e9
    gain: '20'
    instance_index: '0'
    iq_balance: 'False'
    rate: radio_rate
  states: {}
- name: uwb_rfnoc_upsampler_0
  id: uwb_rfnoc_upsampler
  parameters:
    block_args: '""'
    block_type: '"Upsampler"'
    device_select: '0'
    input_rate: radio_rate
    instance_index: '0'
    output_rate: samp_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uwb_scheduled_extractor_0
  id: uwb_scheduled_extractor
  parameters:
    capture_samples: '189696'
    first_packet_sample: first_packet_sample
    packet_interval_s: '0.005'
    pool_size: '16'
    post_guard_samples: '4096'
    pre_guard_samples: '9984'
    sample_rate: samp_rate
    verification_enabled: 'False'
  states: {}
- name: uwb_packet_writer_0
  id: uwb_packet_writer
  parameters:
    base_name: capture
    directory: output_dir
    one_file_per_packet: 'False'
  states: {}

connections:
- [uhd_rfnoc_rx_radio_0, '0', uwb_rfnoc_upsampler_0, '0']
- [uwb_rfnoc_upsampler_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', uwb_scheduled_extractor_0, '0']
- [uwb_scheduled_extractor_0, packet, uwb_packet_writer_0, packet]

metadata:
  file_format: 1
