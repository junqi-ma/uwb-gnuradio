options:
  parameters:
    author: UWB GNU Radio Project
    category: UWB
    comment: File replay through fixed-period scheduled extractor
    description: Extract every predicted radar slot from a CF32 file.
    generate_options: no_gui
    id: uwb_scheduled_file_capture
    output_language: python
    run_options: run
    title: UWB Scheduled File Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 998.4e6
  states: {}
- name: first_packet_sample
  id: variable
  parameters:
    comment: 0-based in input file
    value: '4992000'
  states: {}
- name: input_file
  id: parameter
  parameters:
    label: Input CF32 file
    type: str
    value: '''testdata/uwb_code9_preamble64_payload128_standard_sfd.cfile'''
  states: {}
- name: output_dir
  id: parameter
  parameters:
    label: Output directory
    type: str
    value: '''/tmp/uwb-scheduled-capture'''
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_file
    repeat: 'False'
    type: complex
  states: {}
- name: uwb_scheduled_extractor_0
  id: uwb_scheduled_extractor
  parameters:
    capture_samples: '189696'
    first_packet_sample: first_packet_sample
    packet_interval_s: '0.005'
    pool_size: '16'
    post_guard_samples: '4096'
    pre_guard_samples: '9984'
    sample_rate: samp_rate
    verification_enabled: 'False'
  states: {}
- name: uwb_packet_writer_0
  id: uwb_packet_writer
  parameters:
    base_name: capture
    directory: output_dir
    one_file_per_packet: 'False'
  states: {}

connections:
- [blocks_file_source_0, '0', uwb_scheduled_extractor_0, '0']
- [uwb_scheduled_extractor_0, packet, uwb_packet_writer_0, packet]

metadata:
  file_format: 1
