options:
  parameters:
    author: UWB GNU Radio Project
    comment: Generic energy/coarse/fine packet detector and SC16 writer
    description: Detect packets from a CF32 file and write only captured packets.
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: uwb_detector_to_writer
    output_language: python
    run_options: run
    title: UWB Detector to Writer
  states: {}

blocks:
- name: input_samples
  id: variable
  parameters:
    comment: Exact samples in the default finite test file
    value: '5248448'
  states: {}
- name: tail_samples
  id: variable
  parameters:
    comment: Silence to close the final energy Region
    value: '5000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_file
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (input_samples, tail_samples)
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0j,)*tail_samples
  states: {}
- name: input_file
  id: parameter
  parameters:
    label: Input CF32 file
    type: str
    value: '''testdata/uwb_code9_preamble64_payload128_standard_sfd.cfile'''
  states: {}
- name: output_dir
  id: parameter
  parameters:
    label: Output directory
    type: str
    value: '''/tmp/uwb-detector-capture'''
  states: {}
- name: template_file
  id: parameter
  parameters:
    label: Preamble template
    type: str
    value: '''testdata/reference_preamble.bin'''
  states: {}
- name: uwb_detector_0
  id: uwb_detector
  parameters:
    capture_samples: '200000'
    coarse_decimation: '4'
    coarse_margin: '16'
    coarse_repetitions: '1'
    energy_gate_decimation: '100'
    energy_threshold: '0.001'
    pre_trigger: '2032'
    sample_rate: 998.4e6
    template_file: template_file
  states: {}
- name: uwb_packet_writer_0
  id: uwb_packet_writer
  parameters:
    base_name: capture
    directory: output_dir
    one_file_per_packet: 'False'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_mux_0, '0']
- [blocks_stream_mux_0, '0', uwb_detector_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '1']
- [uwb_detector_0, packet, uwb_packet_writer_0, packet]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
