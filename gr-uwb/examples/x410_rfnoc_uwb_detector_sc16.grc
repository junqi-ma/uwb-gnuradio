options:
  parameters:
    author: UWB GNU Radio Project
    comment: X410 737.28M -> RFNoC 65/48 -> host 998.4M
    description: X410 RFNoC SC16 energy-gated packet detector.
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: x410_rfnoc_uwb_detector_sc16
    output_language: python
    title: X410 RFNoC UWB SC16 Detector
  states: {}

blocks:
- name: radio_rate
  id: variable
  parameters:
    comment: X410 FPGA radio rate
    value: 737.28e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RFNoC upsampler output / host rate
    value: 998.4e6
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
  states: {}
- name: output_dir
  id: parameter
  parameters:
    label: Output directory
    type: str
    value: '''/data/uwb_capture'''
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    block_args: '""'
    dc_offset0: 'False'
    device_select: '0'
    frequency0: 1e9
    gain0: '0'
    instance_index: '0'
    iq_balance0: 'False'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: sc16
  states: {}
- name: uwb_detector_sc16_0
  id: uwb_detector_sc16
  parameters:
    capture_samples: '200000'
    coarse_decimation: '4'
    coarse_margin: '16'
    coarse_repetitions: '1'
    energy_gate_decimation: '100'
    energy_threshold: '0.001'
    pre_trigger: '2032'
    sample_rate: 998.4e6
    template_file: '"testdata/reference_preamble.bin"'
  states: {}
- name: uwb_packet_writer_0
  id: uwb_packet_writer
  parameters:
    base_name: capture
    directory: output_dir
    one_file_per_packet: 'False'
  states: {}
- name: uwb_rfnoc_upsampler_0
  id: uwb_rfnoc_upsampler
  parameters:
    block_args: '""'
    block_type: '"Upsampler"'
    device_select: '0'
    input_rate: radio_rate
    instance_index: '0'
    output_rate: samp_rate
  states: {}

connections:
- {params: {is_back_edge: 'False'}, snk_blk_id: uwb_rfnoc_upsampler_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', uwb_detector_sc16_0, '0']
- [uwb_detector_sc16_0, packet, uwb_packet_writer_0, packet]
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uwb_rfnoc_upsampler_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: 3.10.12.0
